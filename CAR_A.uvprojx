# Keil uVision project CAR_A.uvprojx, settings and files
target car_a (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: car_a +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: automove.c auto_control.c main.c stm32f4xx_it.c system_stm32f4xx.c pwm.c interpreter.c movement.c three_wheel.c encoder.c switch.c fan.c hpwm.c brake.c magnet.c utils.c push_rod.c watchdog.c four_wheel.c suart.c multi_processing.c database.c dma.c mti.c mpu6050.c pid.c us100.c whiteline.c
  group CORE
    ./: usart.c spi.c flash.c
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ./: clock.c
  group Headers
    ./: mti.h multi_processing.h auto_control.h clock.h debug.h encoder.h fan.h hpwm.h i2c.h interpreter.h movement.h pwm.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h switch.h system_stm32f4xx.h usart.h brake.h magnet.h utils.h push_rod.h watchdog.h suart.h spi.h flash.h database.h whiteline.h dma.h car.h
